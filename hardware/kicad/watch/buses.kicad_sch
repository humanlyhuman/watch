File: hardware/kicad/watch/buses.kicad_sch (KiCad schematic)
At the start: 5 parts

Commit message: fah
Parts:
- removed R8: 10k, Footprints:ERJS02_U02__0402_, symbol Symbols:ERJU02F1002X
